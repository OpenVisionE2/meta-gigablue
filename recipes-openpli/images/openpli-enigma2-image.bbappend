IMAGE_INSTALL_remove_gb800solo += "\
	ofgwrite \
	"
