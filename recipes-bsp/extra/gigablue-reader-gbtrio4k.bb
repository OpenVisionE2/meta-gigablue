require gigablue-reader-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbtrio4k)$"

SRCDATE = "20200227"

SRC_URI[md5sum] = "abdbfd7d2ab005b22187bb387c913e33"
SRC_URI[sha256sum] = "befde16a36de1bb29bc5a549eea2e2c1ca92d9855320badb96eca94ee9130c6b"
