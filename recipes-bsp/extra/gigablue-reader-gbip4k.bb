require gigablue-reader-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbip4k)$"

SRCDATE = "20200227"

SRC_URI[md5sum] = "189c3f60dacd1848bf8622ab0a289d94"
SRC_URI[sha256sum] = "961f2fae8ca4ff33c3c0308992b6b9c0f75e89e6fd47a1cba631f255b3b50874"
