require gigablue-platform-util.inc

GBPLATFORM = "gb7252"

SRCDATE = "20200312.r0"

KV = "4.1.20"

SRC_URI[md5sum] = "170b57460dcbfceaae2bf15b09b2adbe"
SRC_URI[sha256sum] = "bcfcb49695f0276e4fac2ed344667d609bf1fe77b6ba1862234df5da78607980"

COMPATIBLE_MACHINE = "^(gbquad4k|gbue4k)$"
